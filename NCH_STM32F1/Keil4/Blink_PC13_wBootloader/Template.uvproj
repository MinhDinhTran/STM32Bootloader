# Keil uVision project Template.uvproj, settings and files
target Template (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Template +hex
  AfterMake: fromelf --bin ".\out\@L.axf" --output ".\out\@L.bin"
  c flags: Optim=1
  c define: STM32F10X_MD, USE_STDPERIPH_DRIVER, HSE_VALUE=8000000
  c include: ..\Blink_PC13_wBootloader;.\lib\STM32F10x_StdPeriph_Lib_V3.5.0\Libraries\STM32F10x_StdPeriph_Driver\inc;.\lib\STM32F10x_StdPeriph_Lib_V3.5.0\Libraries\\CMSIS\CM3\DeviceSupport\ST\STM32F10x
  library: MicroLIB
  memory RVCT4: ROM 0x8002000 size 0xe000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Startup
    ./: system_stm32f10x.c
    ./lib/STM32F10x_StdPeriph_Lib_V3.5.0/Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md.s
  group User
    ./: stm32f10x_it.c stm32f10x_it.h main.c main.h
  group Lib
    ./lib/STM32F10x_StdPeriph_Lib_V3.5.0/Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_rcc.c stm32f10x_gpio.c
